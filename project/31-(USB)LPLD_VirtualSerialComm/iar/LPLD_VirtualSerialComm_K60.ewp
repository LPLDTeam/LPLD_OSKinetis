# IAR project LPLD_VirtualSerialComm_K60.ewp, settings and files
configuration RAM (ARM, debug)
  General.OGChipSelectEditMenu: MK60DX256xxx10 Freescale MK60DX256xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: LPLD_K60; USE_K60D
  ICCARM.CCIncludePath2: ..\app; ..\..\..\lib\CPU; ..\..\..\lib\common; ..\..\..\lib\LPLD; ..\..\..\lib\LPLD\HW; ..\..\..\lib\LPLD\DEV; ..\..\..\lib\uCOS-II\Ports; ..\..\..\lib\uCOS-II\Source; ..\..\..\lib\FatFs; ..\..\..\lib\FatFs\option; ..\..\..\lib\USB\common; ..\..\..\lib\USB\driver; ..\..\..\lib\USB\descriptor; ..\..\..\lib\USB\class
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LPLD_VirtualSerialComm_K60.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\..\lib\iar_config_files\128KB_Ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FLASH (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60DN512xxx10 Freescale MK60DN512xxx10
  ILINK.IlinkIcfFile: ..\..\..\lib\iar_config_files\LPLD_K60DN512_FLASH.icf
configuration BOOT (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  OBJCOPY.OOCOutputFile: LPLD_VirtualSerialComm_K60.bin
  ILINK.IlinkIcfFile: ..\..\..\lib\iar_config_files\LPLD_BOOT_K60DN512.icf
configuration K60FN_FLASH (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60FN1M0xxx12 Freescale MK60FN1M0xxx12
  ICCARM.CCDefines: LPLD_K60; USE_K60F
  ILINK.IlinkIcfFile: ..\..\..\lib\iar_config_files\LPLD_MK60FN1M0VLQ12.icf
  group app
    ../app/: k60_card.h LPLD_VirtualSerialComm.c
  group lib/common
    ../../../lib/common/: alloc.c assert.c assert.h common.h io.c io.h printf.c queue.c queue.h relocate.c relocate.h stdlib.c stdlib.h uif.c uif.h
  group lib/CPU
    ../../../lib/CPU/: MK60DZ10.h startup_K60.s system_MK60.c system_MK60DZ10.h
  group lib/LPLD
    ../../../lib/LPLD/: LPLD_Drivers.h
  group lib/LPLD/DEV
    ../../../lib/LPLD/DEV/: DEV_LCD.c DEV_LCD.h
  group lib/LPLD/HW
    ../../../lib/LPLD/HW/: HW_ADC.c HW_ADC.h HW_CAN.c HW_CAN.h HW_DAC.c HW_DAC.h HW_DMA.c HW_DMA.h HW_ENET.c HW_ENET.h HW_FLASH.c HW_FLASH.h HW_FLEXBUS.c HW_FLEXBUS.h HW_FTM.c HW_FTM.h HW_GPIO.c HW_GPIO.h HW_I2C.c HW_I2C.h HW_LPTMR.c HW_LPTMR.h HW_MCG.c HW_MCG.h HW_PDB.c HW_PDB.h HW_PIT.c HW_PIT.h HW_RTC.c HW_RTC.h HW_SDHC.c HW_SDHC.h HW_SPI.c HW_SPI.h HW_TSI.c HW_TSI.h HW_UART.c HW_UART.h HW_USB.c HW_USB.h HW_WDOG.c HW_WDOG.h
  group lib/USB/class
    ../../../lib/USB/class/: usb_cdc.c usb_cdc.h usb_cdc_pstn.c usb_cdc_pstn.h
  group lib/USB/common
    ../../../lib/USB/common/: derivative.h types.h usb_class.c usb_class.h USB_Config.h usb_framework.c usb_framework.h user_config.h
  group lib/USB/descriptor
    ../../../lib/USB/descriptor/: usb_descriptor_cdc.c usb_descriptor_cdc.h
  group lib/USB/driver
    ../../../lib/USB/driver/: usb_bdt_kinetis.h usb_dci_kinetis.c usb_dci_kinetis.h usb_dciapi.h usb_devapi.h usb_driver.c usb_driver.h virtual_com.c virtual_com.h
